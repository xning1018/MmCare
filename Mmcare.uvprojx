# Keil uVision project Mmcare.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.4.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ FPU2 CLOCK(12000000) ELITTLE
  output: Mmcare +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\API
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c hal_entry.c.bak
  group API
    ./API/: led.c led.h buzzer.c buzzer.h oled.c oled.h OLED_Font.h my1680.c my1680.h radar_uart.c radar_uart.h radar_display.c fall_alarm.c fall_alarm.h radar_display.h ntc_temp.c ntc_temp.h ml307r.h ml307r.c ld2450.h ld2450.c light_sensor.c light_sensor.h ai_fall_engine.c ai_fall_engine.h ai_weights.h
software components: Flex Software:RA Configuration 1.0.0
